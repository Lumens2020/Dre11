# Keil uVision project W2211_GD32.uvprojx, settings and files
target W2211_GD (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F330RB GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.2.0.0
  cpu: IRAM(0x20000000,0x04000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: W2211_GD +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F330
  c include: ..\HARDWARE\GPIO;..\HARDWARE\ADC;..\HARDWARE\EEPROM;..\HARDWARE\EXIT;..\HARDWARE\INIT;..\HARDWARE\IWDG;..\HARDWARE\TIM;..\HARDWARE\UART;..\LIBRARY\GD32F3x0_standard_peripheral\Include;..\LIBRARY\GD32F3x0_standard_peripheral\Source;..\LIBRARY\GD32F3x0_standard_peripheral;..\LIBRARY\CMSIS;..\LIBRARY\CMSIS\GD;..\LIBRARY\CMSIS\GD\GD32F3x0;..\LIBRARY\CMSIS\GD\GD32F3x0\Include;..\LIBRARY\CMSIS\GD\GD32F3x0\Source;..\LIBRARY\CMSIS\GD\GD32F3x0\Source\ARM;..\USER;..\HARDWARE\CONFIG;..\HARDWARE\DMA;..\TEST;..\HARDWARE\EEPROM;..\VOICE;..\..\W2211_MM\W2211_MM32\APP\ADCCONFIG;..\..\W2211_MM\W2211_MM32\APP\AUTOCLEAN;..\..\W2211_MM\W2211_MM32\APP\BLDC;..\..\W2211_MM\W2211_MM32\APP\BRUSH;..\..\W2211_MM\W2211_MM32\APP\CHG;..\..\W2211_MM\W2211_MM32\APP\CLEANWATER;..\..\W2211_MM\W2211_MM32\APP\CONTROL;..\..\W2211_MM\W2211_MM32\APP\DRYCONTROL;..\..\W2211_MM\W2211_MM32\APP\ERROR;..\..\W2211_MM\W2211_MM32\APP\IMPROVE;..\..\W2211_MM\W2211_MM32\APP\KEY;..\..\W2211_MM\W2211_MM32\APP\MODEDEAL;..\..\W2211_MM\W2211_MM32\APP\PUMP;..\..\W2211_MM\W2211_MM32\APP\SEPARATE;..\..\W2211_MM\W2211_MM32\APP\SEWAGE;..\..\W2211_MM\W2211_MM32\APP\TILT;..\..\W2211_MM\W2211_MM32\APP\VOICE;..\..\W2211_MM\W2211_MM32\APP\WATERELEC;..\..\W2211_MM\W2211_MM32\COMM\COMMBLDC;..\..\W2211_MM\W2211_MM32\COMM\COMMBMS;..\..\W2211_MM\W2211_MM32\COMM\COMMDRY;..\..\W2211_MM\W2211_MM32\COMM\COMMFCT;..\..\W2211_MM\W2211_MM32\COMM\COMMSCREEN;..\..\W2211_MM\W2211_MM32\COMM\COMMSPEED;..\..\W2211_MM\W2211_MM32\COMM\COMMTEST;..\..\W2211_MM\W2211_MM32\COMM\UARTCONFIG;..\..\W2211_MM\W2211_MM32\CONFIG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group USER
    ../USER/: main.c gd32f3x0_it.c systick.c main.h
    ../../W2211_MM/W2211_MM32/CONFIG/: config.h
  group LIBRARY
    ../LIBRARY/GD32F3x0_standard_peripheral/Source/: gd32f3x0_adc.c gd32f3x0_cec.c gd32f3x0_cmp.c gd32f3x0_crc.c gd32f3x0_ctc.c gd32f3x0_dac.c gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_fwdgt.c gd32f3x0_gpio.c gd32f3x0_i2c.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_rtc.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_tsi.c gd32f3x0_usart.c gd32f3x0_wwdgt.c
  group STARTUP
    ../LIBRARY/CMSIS/GD/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
  group CMSIS
    ../LIBRARY/CMSIS/GD/GD32F3x0/Source/: system_gd32f3x0.c
  group HARDWARE
    ../HARDWARE/ADC/: gd_adc.c
    ../HARDWARE/EXIT/: gd_exit.c
    ../HARDWARE/GPIO/: gd_gpio.c
    ../HARDWARE/INIT/: gd_init.c
    ../HARDWARE/IWDG/: gd_iwdg.c
    ../HARDWARE/TIM/: gd_tim.c
    ../HARDWARE/UART/: gd_uart.c
    ../HARDWARE/DMA/: gd_dma.c
    ../HARDWARE/EEPROM/: gd_eeprom.c
  group APP
    ../../W2211_MM/W2211_MM32/APP/ADCCONFIG/: adcconfig.c
    ../../W2211_MM/W2211_MM32/APP/AUTOCLEAN/: autoclean.c
    ../../W2211_MM/W2211_MM32/APP/BLDC/: bldc.c
    ../../W2211_MM/W2211_MM32/APP/BRUSH/: brush.c
    ../../W2211_MM/W2211_MM32/APP/CHG/: charge.c
    ../../W2211_MM/W2211_MM32/APP/CLEANWATER/: cleanwater.c
    ../../W2211_MM/W2211_MM32/APP/CONTROL/: control.c
    ../../W2211_MM/W2211_MM32/APP/DRYCONTROL/: drycontrol.c
    ../../W2211_MM/W2211_MM32/APP/ERROR/: error.c
    ../../W2211_MM/W2211_MM32/APP/IMPROVE/: improve.c
    ../../W2211_MM/W2211_MM32/APP/KEY/: key.c keyAD.c keyIO.c
    ../../W2211_MM/W2211_MM32/APP/MODEDEAL/: modedeal.c
    ../../W2211_MM/W2211_MM32/APP/PUMP/: waterpump.c
    ../../W2211_MM/W2211_MM32/APP/SEPARATE/: separate.c
    ../../W2211_MM/W2211_MM32/APP/SEWAGE/: sewage.c
    ../../W2211_MM/W2211_MM32/APP/TILT/: tilt.c
    ../../W2211_MM/W2211_MM32/APP/VOICE/: voice.c voicelist.c
    ../../W2211_MM/W2211_MM32/APP/WATERELEC/: waterelec.c
  group TEST
    ../TEST/: uarttest.c
  group COMM
    ../../W2211_MM/W2211_MM32/COMM/COMMBLDC/: commbldc.c
    ../../W2211_MM/W2211_MM32/COMM/COMMBMS/: commbms.c
    ../../W2211_MM/W2211_MM32/COMM/COMMDRY/: commdry.c
    ../../W2211_MM/W2211_MM32/COMM/COMMFCT/: commfct.c
    ../../W2211_MM/W2211_MM32/COMM/COMMSCREEN/: commscreen.c
    ../../W2211_MM/W2211_MM32/COMM/COMMTEST/: commtest.c
    ../../W2211_MM/W2211_MM32/COMM/UARTCONFIG/: uartconfig.c
  group VOICE
    ../VOICE/: commvoice.c
